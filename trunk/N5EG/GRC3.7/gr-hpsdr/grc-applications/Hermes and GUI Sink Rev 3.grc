<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RxFreq0</value></param>
<param><key>value</key><value>7200000</value></param>
<param><key>start</key><value>7000000</value></param>
<param><key>stop</key><value>7300000</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>700</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RxFreq1</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>start</key><value>500000</value></param>
<param><key>stop</key><value>1600000</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>RxFreq0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>RxFreq0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>hpsdr_hermesNB</key>
<param><key>id</key><value>hpsdr_hermesNB_0</value></param>
<param><key>Rx0F</key><value>RxFreq0</value></param>
<param><key>Rx1F</key><value>RxFreq1</value></param>
<param><key>TxF</key><value>7200000</value></param>
<param><key>RxSmp</key><value>samp_rate</value></param>
<param><key>RxPre</key><value>0</value></param>
<param><key>PTTRx</key><value>1</value></param>
<param><key>PTTTx</key><value>1</value></param>
<param><key>PTTmode</key><value>0</value></param>
<param><key>TxDrive</key><value>0</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>Intfc</key><value>"eth0"</value></param>
<param><key>CkS</key><value>"0xF8"</value></param>
<param><key>AlexC</key><value>"0x00000000"</value></param>
</block>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>hpsdr_hermesNB_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
